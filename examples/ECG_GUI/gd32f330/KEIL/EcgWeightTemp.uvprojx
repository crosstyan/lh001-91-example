# Keil uVision project EcgWeightTemp.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: GD32F330F8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EcgWeightTemp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: GD32F330,SYS_TICK_DELAY
  c include: ..\..\..\..\lh_lib;..\..\..\..\mcu\gd32f330\lib\inc;..\..\..\..\mcu\gd32f330\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group application
    ../: main.c adaptive_lms.c lh_ecg.c panTompkins.c process_cmd.c uart_frame.c
  group lh_lib
    ../../../../lh_lib/: LH001_91.c
  group mcu_lib
    ../../../../mcu/gd32f330/lib/src/: gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group port
    ../../../../mcu/gd32f330/port/: spi_port.c uart_print.c
software components: CMSIS:CORE 5.6.0, Device:GD32F3x0_StdPeripherals:MISC 2.0.0, Device:GD32F3x0_StdPeripherals:RCU 2.0.0, Device:GD32F3x0_libopt 2.0.0, Device:Startup 2.0.0
